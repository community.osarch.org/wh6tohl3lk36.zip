Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: GIS surface style.ifc
Time: 2024-08-20T18:30:36+02:00
Written by: IfcOpenShell 0.7.11-alpha240820
Made in: Bonsai 0.7.11-alpha240820-71ddc63
Authorization: Nobody

# IfcGeographicElement, Ortho IGN_ORTHO_WM_lamb
In: My Storey
PredefinedType: TERRAIN; Material: sat mat
